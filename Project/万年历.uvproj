# Keil uVision project 万年历.uvproj, settings and files
target Calendar-DEMO (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 万年历 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS\CM3;..\FWlib\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP Code
    ../CMSIS/CM3/startup/arm/: startup_stm32f10x_hd.s
  group user
    ../User/: calendar.c date.c main.c stm32f10x_it.c
  group lib
    ../FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c
  group cmsis
    ../CMSIS/CM3/: core_cm3.c system_stm32f10x.c
